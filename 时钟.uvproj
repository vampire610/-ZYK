# Keil uVision project 时钟.uvproj, settings and files
target clock (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code;.\code\my
  group my
    ./: STARTUP.A51
    ./code/: main.c
    ./code/my/: interrupt.c calculate.c display.c keypad.c
